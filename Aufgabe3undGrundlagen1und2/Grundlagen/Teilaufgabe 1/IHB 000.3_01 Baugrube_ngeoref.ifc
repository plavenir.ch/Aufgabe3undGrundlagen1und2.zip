Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: Baugrube.ifc
Time: 2025-05-05T15:14:13
Author: Sarah Harzenmoser
Organization: F. Preisig AG, Schreinerstrasse 1, CH-9000 St. Gallen
Written by: ODA SDAI 24.5
Authorization: has

# IfcProject, 9011 has - 3 - Wasserfurri
AllplanAttributes - Bauherr: Bauherr Name; Architekt: Architekt Name; Bauort: PLZ und Ort; Bauunternehmer Straße: Bauunternehmer Strasse; Bauunternehmer Plz/Ort: Bauunternehmer PLZ Ort; Bauherr Straße: Bauherr Strasse; Bauherr Plz/Ort: Bauherr PLZ Ort; Architekt Straße: Architekt Strasse; Architekt Plz/Ort: Architekt PLZ Ort; Projektbeschreibung: Projektbeschreibung; Geographische Länge: 2695855; Geographische Breite: 1261000; Bauunternehmer: Bauunternehmer Name

# IfcSite, Modelle auf dem Nullpunkt
RefLatitude: 48, 8, 10, 320000; RefLongitude: 11, 41, 19, 320000

# IfcBuildingElementProxy (3)
In: Gelände
Name | Bezeichnung | Allright_Bauteil_ID | Abrechnungsart | Objektname | Text1 | Text2 | Typ = Elementbezeichnung | Attributset-Objekt | Status | Tragendes Bauteil = Barrierefrei = öffentlich zugänglich
Baugrube | Baugrube | 0301Mak0000009011 | St | Makro | AllplanAttributes - V6: 0 m; V7: 0 m; V8: 0 m; V9: 0
Kontrollpunkt | Kontrollpunkt | 0301ErE0000039378 | m³ | Kontrollpunkt | X = 2695881.75 | Y = 1261014.30 | Kontrollpunkt | Space | Neubau | no
Kontrollpunkt | Kontrollpunkt | 0301ErE0000039379 | m³ | Kontrollpunkt | X = 2695833.95 | Y = 1261009.75 | Kontrollpunkt | Space | Neubau | no | AllplanAttributes - X_Koordinate: 0 m; Y_Koordinate: 0 m; Achsenendpunkt (X): 0 m
